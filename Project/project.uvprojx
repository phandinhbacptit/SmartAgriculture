# Keil uVision project project.uvprojx, settings and files
target SmartAgriculture (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\include;..\Libraries\stdLibrary\STM32F10x_StdPeriph_Driver\inc;..\Libraries\userLibrary\inc;..\Libraries\stdLibrary\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SourceCode
    ./Source/: main.c stm32f10x_it.c
  group CMSIS
    ../Libraries/stdLibrary/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/stdLibrary/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Peripheral
    ../Libraries/stdLibrary/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_dbgmcu.c stm32f10x_sdio.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_flash.c
  group UserLibrary
    ../Libraries/userLibrary/src/: stm32_usart.c stm32_io.c stm32_delay.c stm32_timer.c control.c 74hc595.c save_time_run_dc.c STM32F1_my_FLASH.c
  group startup
    ../Libraries/stdLibrary/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
